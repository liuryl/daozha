# Keil uVision project cheku.uvproj, settings and files
target cheku (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: cheku +hex
  c flags: Optimize=8 SizeSpeed=1
  group code User
    ./: main.c Uart.c Uart.h Wifi.h Wifi.c MQTT.h MQTT.c delay.c delay.h distance.h distance.c motor.h motor.c
